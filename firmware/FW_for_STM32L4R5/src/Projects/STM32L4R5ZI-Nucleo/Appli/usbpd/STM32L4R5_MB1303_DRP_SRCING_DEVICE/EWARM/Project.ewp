# IAR project Project.ewp, settings and files
configuration Nucleo_STM32L4R5_MB1303_DRP_SRCING_DEVICE (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R5xx; USE_HAL_DRIVER; USE_HAL_DRIVER; _RTOS; USBPD_LED_SERVER; USBPD_PORT_COUNT=1; _DRP; _SNK; MB1303; USE_FULL_LL_DRIVER; USBPD_STUSB1602; SPI_ONE_LINE_na; CONF_NORMAL; USBPDCORE_LIB_PD3_FULL; _TRACE; _ERROR_RECOVERY; _VCONN_SUPPORT; SOURCING_DEVICE; _SRC_CAPA_EXT; _ADC_MONITORING; _VDM; _MANU_INFO_na; _ALERT; _STATUS; _BATTERY_na; USBPD_USBDATA; _CLASS_BB_na; _CLASS_HID; USE_USB_FS; _UNCHUNKED_SUPPORT_na
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-L4R5; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-L4R5; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\Components\STUSB1602; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Utilities\TRACER_EMB; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STUSB1602\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\Billboard\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\..\..\..\..\Utilities\LED_SERVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32L4R5xx
  AARM.AUserIncludes: ..\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: STM32L4R5_MB1303_DRP_SRCING_DEVICE.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkConfigDefines: __ICFEDIT_size_cstack__=0x1000; __ICFEDIT_size_heap__=0xC00
  ILINK.IlinkIcfFile: stm32l4r5xx_flash.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c usbpd_dpm_user.c usbpd_vdm_user.c usbpd_pwr_if.c usbd_conf.c usbd_desc.c
  group Application/EWARM
    ./: startup_stm32l4r5xx.s
  group Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/ST/STM32_USB_Device_Library/Class/Billboard
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/Billboard/Src/: usbd_billboard.c
  group Middlewares/ST/STM32_USB_Device_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM4_wc32.a
  group Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602/src/: usbpd_cad_hw_if.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_timersserver.c usbpd_phy.c usbpd_Stusb_Dpm_if.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Drivers/BSP/Components/STUSB1602
    ../../../../../../Drivers/BSP/Components/STUSB1602/: STUSB1602_Peripherals_if.c STUSB1602_Registers_if.c USBPD_CUST_NVM_API.c
  group Drivers/BSP/P-NUCLEO-L4R5
    ../../../../../../Drivers/BSP/P-NUCLEO-L4R5/: p-nucleo-L4R5.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_ll_utils.c stm32l4xx_ll_usart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_ll_spi.c stm32l4xx_hal_hcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Utilities/TRACER_EMB
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
  group Utilities/LED_SERVER
    ../../../../../../Utilities/LED_SERVER/: led_server.c
